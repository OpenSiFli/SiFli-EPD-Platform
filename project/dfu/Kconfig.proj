## project/dfu/Kconfig.proj
```kconfig
config CUSTOM_MEM_MAP
    bool
    select custom_mem_map
    default y

config EPD_TF_DFU
    bool
    default y
```
